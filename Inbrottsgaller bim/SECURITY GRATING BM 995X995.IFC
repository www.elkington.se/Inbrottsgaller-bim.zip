Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SECURITY GRATING BM 995X995.IFC
Time: 2019-04-05T06:23:04
Author: com2it
Organization: Hewlett-Packard Company
Written by: SwIFC
Made in: SolidWorks 2015

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: SECURITY GRATING-A-BM-995 (2)
In: Default Storey
Name
SECURITY GRATING-A-BM-995 | PSet_Mass_Property - Mass Measure: 25.4589; Area Measure: 1.25984 m2; Volume Measure: 0.00326396 m3
SECURITY GRATING-A-BM-995
